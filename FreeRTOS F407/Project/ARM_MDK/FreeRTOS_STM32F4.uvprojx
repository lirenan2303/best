# Keil uVision project FreeRTOS_STM32F4.uvprojx, settings and files
target FreeRTOS_STM32F4 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_STM32F4 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\Libraries;..\..\Libraries\CORE;..\..\Libraries\FWLIB\inc;..\..\FreeRTOS;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\USER;..\..\ZKLib_STM32F4;..\..\ZKLib_STM32F4\stm32
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Libraries/CORE/: core_cm4.h core_cmSimd.h
    ../../Libraries/StartUp/: startup_stm32f40_41xxx.s
    ../../Libraries/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../../Libraries/FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_dma.c
  group USER
    ../../USER/: FreeRTOS_Hook.c ballast_comm.c electric.c gsm.c main.c time_plan.c sys_debug.c gateway_protocol.c ballast_protocol.c
  group FreeRTOS
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../FreeRTOS/Source/: list.c queue.c tasks.c
  group ZKLib_STM32F4
    ../../ZKLib_STM32F4/stm32/: rtc.c fsmc_nor.c norflash.c uart_debug.c
